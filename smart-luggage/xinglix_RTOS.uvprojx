# Keil uVision project xinglix_RTOS.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xinglix_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: -Wno-padded -Wno-conversion -Wno-missing-noreturn -Wno-missing-variable-declarations -Wno-covered-switch-default -Wno-overlength-strings -Wno-missing-braces -Wno-missing-prototypes -Wno-format-nonliteral
  c include: .\code;.\lib;.\start;.\module;.\FreeRTOS\include;.\FreeRTOS\portable\ARM_CM3;.\FreeRTOS\portable;.\FreeRTOS\source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group code
    ./code/: main.c log.h log.c ui.h ui.c gps.h gps.c lock.h lock.c sys_state.h sys_state.c alarm.h alarm.c secrets.h secrets.h.example stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h
  group lib
    ./lib/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group start
    ./start/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group module
    ./module/: Uart.h Uart.c ZW101.h ZW101.c ZW101_Command.h WIFI.h WIFI.c WIFI_Command.h WIFI_Command.c key.c key.h BUZ.c BUZ.h OLED.c OLED.h OLED_Data.c OLED_Data.h
  group FreeRTOS_Protable
    ./FreeRTOS/portable/: heap_4.c
    ./FreeRTOS/portable/ARM_CM3/: port.c portmacro.h
  group FreeRTOS_Source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
